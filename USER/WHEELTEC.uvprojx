# Keil uVision project WHEELTEC.uvprojx, settings and files
target Akm_Car (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Akm_Car +hex
  BeforeMake: .\hexbinHandle.bat
  AfterMake: .\copyhex.bat
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,__TARGET_FPU_VFP,ARM_MATH_CM4,__CC_ARM,USE_USB_OTG_FS,AKM_CAR
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FWLIB\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\BALANCE\Inc;..\HARDWARE\Inc;..\USER;..\CarType\Inc;..\HARDWARE\ICM20948;..\HARDWARE\MPU6050;..\USB_HOST\App;..\USB_HOST\Target;..\MiddleWares\STM32_USB_Host_Library\Core\Inc;..\MiddleWares\STM32_USB_Host_Library\Class\HID\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Updatelog
    ../: 更新记录.txt
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_tim.c stm32f4xx_pwr.c stm32f4xx_dma.c stm32f4xx_hal_hcd.c stm32f4xx_ll_usb.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group USER
    ./: main.c system.c stm32f4xx_it.c system_stm32f4xx.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/: adc.c auto_recharge.c can.c buzzer.c encoder.c enable_key.c I2C.c key.c LED.C motor.c bts7960.c oled.c remote.c stmflash.c uartx.c driver_d50a.c bsp_gamepad.c ps2_classic.c bsp_RGBLight.c
    ../HARDWARE/ICM20948/: ICM20948.c
    ../HARDWARE/MPU6050/: MPU6050.c
  group CarType
    ../CarType/: akm_robot_init.c diff_robot_init.c mec_robot_init.c 4wd_robot_init.c omni_robot_init.c
  group Balance
    ../BALANCE/: balance_task.c imu_task.c show_task.c led_task.c chassis_uart_control.c ps2_task.c data_task.c uartx_callback.c can_callback.c timx_callback.c reportErr_task.c
  group Middlewares/USB_Host_Library
    ../MiddleWares/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../MiddleWares/STM32_USB_Host_Library/Class/HID/Src/: usbh_hid.c usbh_hid_keybd.c usbh_hid_mouse.c usbh_hid_parser.c
  group USB_Host/Target
    ../USB_HOST/Target/: usbh_conf.c
  group USB_Host/App
    ../USB_HOST/App/: usb_host.c usbh_os_middleware.c usbh_hid_GamePad.c xbox360_gamepad.c WiredPS2_gamepad.c
target Diff_Car (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: as above
  output: Diff_Car +hex
  AfterMake: .\copyhex.bat
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,__TARGET_FPU_VFP,ARM_MATH_CM4,__CC_ARM,USE_USB_OTG_FS,DIFF_CAR
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\CarType\Inc;..\BALANCE\Inc;..\HARDWARE\Inc;..\HARDWARE\MPU6050;..\HARDWARE\ICM20948;..\MiddleWares\STM32_USB_Host_Library\Class\HID\Inc;..\MiddleWares\STM32_USB_Host_Library\Core\Inc;..\USB_HOST\App;..\USB_HOST\Target
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target Diff_Car_MotorA_Test (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: as above
  output: Diff_Car_MotorA_Test +hex
  AfterMake: .\copyhex.bat
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,__TARGET_FPU_VFP,ARM_MATH_CM4,__CC_ARM,USE_USB_OTG_FS,DIFF_CAR,CHASSIS_MOTOR_A_PROBE=1
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target Diff_Car_MotorB_Test (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: as above
  output: Diff_Car_MotorB_Test +hex
  AfterMake: .\copyhex.bat
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,__TARGET_FPU_VFP,ARM_MATH_CM4,__CC_ARM,USE_USB_OTG_FS,DIFF_CAR,CHASSIS_MOTOR_B_PROBE=1
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target Diff_Car_ClosedLoop_Test (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: as above
  output: Diff_Car_ClosedLoop_Test +hex
  AfterMake: .\copyhex.bat
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,__TARGET_FPU_VFP,ARM_MATH_CM4,__CC_ARM,USE_USB_OTG_FS,DIFF_CAR,CHASSIS_CLOSED_LOOP_TEST=1
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target Diff_Car_PC8_Test (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: as above
  output: Diff_Car_PC8_Test +hex
  AfterMake: .\copyhex.bat
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,__TARGET_FPU_VFP,ARM_MATH_CM4,__CC_ARM,USE_USB_OTG_FS,DIFF_CAR,CHASSIS_PC8_PIN_TEST=1
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target Mec_Car (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: as above
  output: Mec_Car +hex
  BeforeMake: .\hexbinHandle.bat
  AfterMake: fromelf --bin --output=..\Mec_Car.bin ..\OBJ\Mec_Car.axf
  AfterMake: .\copyhex.bat
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,__TARGET_FPU_VFP,ARM_MATH_CM4,__CC_ARM,USE_USB_OTG_FS,MEC_CAR
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\BALANCE\Inc;..\CarType\Inc;..\HARDWARE\Inc;..\HARDWARE\ICM20948;..\HARDWARE\MPU6050;..\USB_HOST\App;..\USB_HOST\Target;..\MiddleWares\STM32_USB_Host_Library\Class\HID\Inc;..\MiddleWares\STM32_USB_Host_Library\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target 4WD_Car (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: as above
  output: 4WD_Car +hex
  BeforeMake: .\hexbinHandle.bat
  AfterMake: fromelf --bin --output=..\4WD_Car.bin ..\OBJ\4WD_Car.axf
  AfterMake: .\copyhex.bat
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,__TARGET_FPU_VFP,ARM_MATH_CM4,__CC_ARM,USE_USB_OTG_FS,_4WD_CAR
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target Omni_Car (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: as above
  output: Omni_Car +hex
  BeforeMake: .\hexbinHandle.bat
  AfterMake: .\copyhex.bat
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,__TARGET_FPU_VFP,ARM_MATH_CM4,__CC_ARM,USE_USB_OTG_FS,OMNI_CAR
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
